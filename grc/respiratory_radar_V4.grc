options:
  parameters:
    author: FIU EEE 4550/5557 Radar Systems, Group 04
    description: '5.95 GHz CW Doppler respiratory-rate radar on an ADALM-Pluto: 100 kHz IF tone, 2000:1 decimation to 500 S/s, phase unwrap, 0.1-0.5 Hz bandpass, three independent BPM estimators, and a separate motion-detection path.'
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: respiratory_radar
    output_language: python
    title: CW Doppler Respiratory Radar (V4)
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '5950000000'
  states: {}
- name: phase_rate
  id: variable
  parameters:
    value: samp_rate / 100 / 100
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '3200'
    long_form: 'True'
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Phase unwrap: removes +/-2*pi discontinuities"""
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Phase Unwrap',
                  in_sig=[np.float32],
                  out_sig=[np.float32])
              self.last_in = 0.0
              self.accum = 0.0

          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]
              # running unwrap: track cumulative offset
              diff = np.diff(np.concatenate(([self.last_in], x)))
              # wrap each diff into [-pi, pi]
              diff_wrapped = (diff + np.pi) % (2*np.pi) - np.pi
              # reconstruct unwrapped signal
              unwrapped = self.accum + np.cumsum(diff_wrapped)
              out[:] = unwrapped.astype(np.float32)
              # update state for next call
              self.last_in = float(x[-1])
              self.accum = float(unwrapped[-1])
              return len(out)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Phase unwrap: removes +/-2*pi discontinuities"""
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Phase Unwrap',
                  in_sig=[np.float32],
                  out_sig=[np.float32])
              self.last_in = 0.0
              self.accum = 0.0

          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]
              # running unwrap: track cumulative offset
              diff = np.diff(np.concatenate(([self.last_in], x)))
              # wrap each diff into [-pi, pi]
              diff_wrapped = (diff + np.pi) % (2*np.pi) - np.pi
              # reconstruct unwrapped signal
              unwrapped = self.accum + np.cumsum(diff_wrapped)
              out[:] = unwrapped.astype(np.float32)
              # update state for next call
              self.last_in = float(x[-1])
              self.accum = float(unwrapped[-1])
              return len(out)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """
          Absolute phase derivative block.

          Input:
              float32 phase samples in radians

          Output:
              float32 |dphi/dn|

          Use:
              Connect this block's output to a QT GUI Time Sink to plot it.
          """

          def __init__(self, wrap_phase=True):
              super().__init__(
                  name="Abs Phase Derivative",
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              self.wrap_phase = bool(wrap_phase)
              self.last = 0.0

          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]

              n = len(x)
              if n == 0:
                  return 0

              dphi = np.diff(np.concatenate(([self.last], x)))

              if self.wrap_phase:
                  dphi = (dphi + np.pi) % (2.0 * np.pi) - np.pi

              out[:n] = np.abs(dphi).astype(np.float32)

              self.last = float(x[-1])
              return n
    wrap_phase: 'False'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Motion Detector — GNU Radio Embedded Python Block
      ===================================================
      Place this after your Abs Phase Derivative block.
      It compares the input against a threshold and outputs
      1.0 (motion detected) or 0.0 (no motion).

      Uses a short averaging window to avoid triggering on
      single-sample noise spikes.

      GNU Radio setup:
        Abs Phase Derivative ──► [this block] ──► QT GUI Time Sink
                                                   (Sample Rate: 500)
                                               ──► QT GUI Number Sink
                                                   (Sample Rate: 500)

      Parameters:
        threshold   : phase derivative threshold in rad/sample (default 0.05)
                      Start with 0.05 and adjust based on your setup.
                      - Too low → triggers on noise
                      - Too high → misses subtle motion
        avg_window  : number of samples to average over (default 50)
                      At 500 samp/s, 50 samples = 100 ms averaging window.
                      This smooths out single-sample noise spikes.
        hold_samples: how long to keep "motion detected" after the last
                      trigger (default 500 = 1 second at 500 samp/s).
                      Prevents rapid flickering between states.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Motion detector: thresholds abs phase derivative."""

          def __init__(self, threshold=0.05, avg_window=50, hold_samples=500):
              gr.sync_block.__init__(
                  self,
                  name="Motion Detector",
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              self.threshold = float(threshold)
              self.avg_window = int(avg_window)
              self.hold_samples = int(hold_samples)

              # Ring buffer for running average
              self.ring = np.zeros(self.avg_window, dtype=np.float32)
              self.ring_idx = 0
              self.ring_sum = 0.0

              # Hold timer: counts down from hold_samples after last trigger
              self.hold_counter = 0

          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]
              n = len(x)

              for i in range(n):
                  # Update running average
                  old_val = self.ring[self.ring_idx]
                  self.ring[self.ring_idx] = x[i]
                  self.ring_sum += x[i] - old_val
                  self.ring_idx = (self.ring_idx + 1) % self.avg_window

                  avg = self.ring_sum / self.avg_window

                  # Check threshold
                  if avg > self.threshold:
                      self.hold_counter = self.hold_samples
                      out[i] = 1.0
                  elif self.hold_counter > 0:
                      self.hold_counter -= 1
                      out[i] = 1.0
                  else:
                      out[i] = 0.0

              return n
    avg_window: '50'
    hold_samples: '500'
    threshold: '0.1'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """FFT BPM estimator (Hann window, linear detrend, log-parabolic peak interpolation).

          Every window_sec seconds the last window_sec of the bandpassed breathing
          phase is detrended, Hann-windowed, zero-padded to fft_size and transformed.
          The strongest bin in [f_low, f_high] is refined with a parabolic fit on the
          log spectrum and reported in BPM. An estimate is accepted only when

            * the record's peak-to-peak amplitude is at least min_pp radians, and
            * the peak is at least snr_gate times the median of the in-band bins
              that lie outside the window's main lobe (+/- 2/T Hz for Hann).

          The second rule is what makes such a narrow band workable. A 15 s record
          has a main lobe about 0.27 Hz wide, most of the 0.1-0.5 Hz band, so
          comparing the peak with the median of *all* in-band bins (as the first
          version did, with a 4-term Blackman-Harris window and an even wider lobe)
          rejected clean breathing near the band centre. Until an estimate is
          accepted the output is 0.0; afterwards the last accepted value is held.
          """

          def __init__(self, samp_rate=500.0, window_sec=15.0, fft_size=32768,
                       f_low=0.1, f_high=0.5, snr_gate=6.0, min_pp=0.005):
              gr.sync_block.__init__(self, name='FFT BPM Estimator',
                                     in_sig=[np.float32], out_sig=[np.float32])
              self.samp_rate = float(samp_rate)
              self.window_len = int(self.samp_rate * float(window_sec))
              # Never crop the record: pad to at least the next power of two above it.
              self.fft_size = max(int(fft_size), 1 << (self.window_len - 1).bit_length())
              self.snr_gate = float(snr_gate)
              self.min_pp = float(min_pp)
              self.buffer = np.zeros(self.window_len, dtype=np.float32)
              self.buf_idx = 0
              self.filled = False
              self.current_bpm = 0.0
              self.last_peak_ratio = 0.0     # diagnostic: peak / noise reference at the last update
              self.freqs = np.fft.rfftfreq(self.fft_size, d=1.0 / self.samp_rate)
              self.band_mask = (self.freqs >= float(f_low)) & (self.freqs <= float(f_high))
              self.mainlobe_hz = 2.0 * self.samp_rate / self.window_len
              n_arr = np.arange(self.window_len, dtype=np.float64)
              self.win = (0.5 - 0.5 * np.cos(2.0 * np.pi * n_arr / (self.window_len - 1))).astype(np.float32)
              self.bin_hz = self.freqs[1] - self.freqs[0]
              self.detrend_t = np.arange(self.window_len, dtype=np.float32)
              self.update_every = self.window_len
              self.since_update = 0

          def _push(self, x):
              n = len(x)
              L = self.window_len
              if n >= L:                      # a chunk bigger than the window replaces it
                  self.buffer[:] = x[-L:]
                  self.buf_idx = 0
                  self.filled = True
                  return
              end = self.buf_idx + n
              if end <= L:
                  self.buffer[self.buf_idx:end] = x
              else:
                  first = L - self.buf_idx
                  self.buffer[self.buf_idx:] = x[:first]
                  self.buffer[:n - first] = x[first:]
              self.buf_idx = (self.buf_idx + n) % L
              if end >= L:
                  self.filled = True

          def _compute_bpm(self):
              sig = np.concatenate((self.buffer[self.buf_idx:], self.buffer[:self.buf_idx]))
              if float(np.max(sig) - np.min(sig)) < self.min_pp:
                  return
              coef = np.polyfit(self.detrend_t, sig, 1)
              sig = sig - (coef[0] * self.detrend_t + coef[1])
              spec = np.abs(np.fft.rfft(sig * self.win, n=self.fft_size)) ** 2
              band = np.where(self.band_mask, spec, 0.0)
              k = int(np.argmax(band))
              if k == 0 or k >= len(spec) - 1:
                  return
              # Noise reference: in-band bins clear of the main lobe around the peak.
              offset = np.abs(self.freqs - self.freqs[k])
              ref = self.band_mask & (offset > self.mainlobe_hz)
              if np.count_nonzero(ref) < 3:
                  ref = self.band_mask & (offset > 0.5 * self.mainlobe_hz)
              noise = float(np.median(spec[ref])) + 1e-30 if np.any(ref) else 1e-30
              self.last_peak_ratio = float(spec[k]) / noise
              if self.last_peak_ratio < self.snr_gate:
                  return
              a = np.log(spec[k - 1] + 1e-30)
              b = np.log(spec[k] + 1e-30)
              c = np.log(spec[k + 1] + 1e-30)
              d = a - 2.0 * b + c
              delta = 0.5 * (a - c) / d if d != 0 else 0.0
              peak_freq = self.freqs[k] + delta * self.bin_hz
              self.current_bpm = float(np.clip(peak_freq * 60.0, 0.0, 60.0))

          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]
              n = len(x)
              self._push(x)
              self.since_update += n
              if self.filled and self.since_update >= self.update_every:
                  self._compute_bpm()
                  self.since_update = 0
              out[:n] = np.float32(self.current_bpm)
              return n
    f_high: '0.5'
    f_low: '0.1'
    fft_size: '32768'
    min_pp: ''
    samp_rate: '500'
    snr_gate: ''
    window_sec: '15'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Zero-crossing BPM estimator with a peak-to-peak adaptive Schmitt trigger.

          The thresholds sit at centre +/- frac_of_pp * pp / 2, where centre and pp
          are the mid-point and peak-to-peak of the last window_sec seconds, so the
          trigger rescales itself to whatever amplitude the subject produces. A
          crossing is counted once per cycle (arm below the low threshold, fire
          above the high one), and BPM = (crossings - 1) * 60 / time between the
          first and last crossing in the window. Output is 0.0 until two crossings
          exist or while pp < min_pp (no subject).
          """

          def __init__(self, samp_rate=500.0, window_sec=15.0,
                       frac_of_pp=0.3, min_pp=0.005):
              gr.sync_block.__init__(self, name='ZC BPM Estimator',
                                     in_sig=[np.float32], out_sig=[np.float32])
              self.fs = float(samp_rate)
              self.win_samples = int(self.fs * float(window_sec))
              self.frac = float(frac_of_pp)
              self.min_pp = float(min_pp)
              self.stats_buf = np.zeros(self.win_samples, dtype=np.float32)
              self.stats_idx = 0
              self.stats_full = False
              self.center = 0.0
              self.thresh_high = 0.0
              self.thresh_low = 0.0
              self.have_thresh = False
              self.armed = True
              self.crossings = []
              self.n_abs = 0
              self.bpm = 0.0

          def _push(self, x):
              n = len(x)
              L = self.win_samples
              if n >= L:                      # a chunk bigger than the window replaces it
                  self.stats_buf[:] = x[-L:]
                  self.stats_idx = 0
                  self.stats_full = True
                  return
              end = self.stats_idx + n
              if end <= L:
                  self.stats_buf[self.stats_idx:end] = x
              else:
                  first = L - self.stats_idx
                  self.stats_buf[self.stats_idx:] = x[:first]
                  self.stats_buf[:n - first] = x[first:]
              self.stats_idx = (self.stats_idx + n) % L
              if end >= L:
                  self.stats_full = True

          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]
              n = len(x)
              self._push(x)
              if self.stats_full:
                  hi = float(np.max(self.stats_buf))
                  lo = float(np.min(self.stats_buf))
                  pp = hi - lo
                  if pp >= self.min_pp:
                      self.center = (hi + lo) / 2.0
                      half = self.frac * pp / 2.0
                      self.thresh_high = self.center + half
                      self.thresh_low = self.center - half
                      self.have_thresh = True
                  else:
                      self.have_thresh = False
              if self.have_thresh:
                  for i in range(n):
                      v = x[i]
                      if self.armed:
                          if v > self.thresh_high:
                              self.crossings.append(self.n_abs + i)
                              self.armed = False
                      elif v < self.thresh_low:
                          self.armed = True
              self.n_abs += n
              cutoff = self.n_abs - self.win_samples
              self.crossings = [t for t in self.crossings if t >= cutoff]
              if len(self.crossings) >= 2:
                  span_sec = (self.crossings[-1] - self.crossings[0]) / self.fs
                  if span_sec > 0:
                      self.bpm = (len(self.crossings) - 1) * 60.0 / span_sec
              else:
                  self.bpm = 0.0
              out[:n] = np.float32(self.bpm)
              return n
    frac_of_pp: '0.3'
    min_pp: '0.005'
    samp_rate: '500'
    window_sec: '15.0'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Autocorrelation BPM estimator (immune to DC offset and slow drift).

          Every window_sec seconds the mean is removed from the last window_sec of
          signal and its autocorrelation is computed through the FFT
          (Wiener-Khinchin, zero-padded to avoid circular wrap). The first peak in
          the lag range 60/bpm_max .. 60/bpm_min seconds gives the period; a
          parabolic fit on the three lags around it refines it. Peaks with a
          normalised correlation below corr_threshold are ignored. Output is 0.0
          until the first accepted estimate, then holds the last one.
          """

          def __init__(self, samp_rate=500.0, window_sec=60.0,
                       bpm_min=3.0, bpm_max=30.0, corr_threshold=0.3):
              gr.sync_block.__init__(self, name='AC BPM Estimator',
                                     in_sig=[np.float32], out_sig=[np.float32])
              self.fs = float(samp_rate)
              self.window_len = int(self.fs * float(window_sec))
              self.bpm_min = float(bpm_min)
              self.bpm_max = float(bpm_max)
              self.corr_threshold = float(corr_threshold)
              self.tau_min = int(self.fs * 60.0 / self.bpm_max)
              self.tau_max = int(self.fs * 60.0 / self.bpm_min)
              self.buffer = np.zeros(self.window_len, dtype=np.float32)
              self.buf_idx = 0
              self.filled = False
              self.current_bpm = 0.0
              self.update_every = self.window_len
              self.since_update = 0

          def _push(self, x):
              n = len(x)
              L = self.window_len
              if n >= L:                      # a chunk bigger than the window replaces it
                  self.buffer[:] = x[-L:]
                  self.buf_idx = 0
                  self.filled = True
                  return
              end = self.buf_idx + n
              if end <= L:
                  self.buffer[self.buf_idx:end] = x
              else:
                  first = L - self.buf_idx
                  self.buffer[self.buf_idx:] = x[:first]
                  self.buffer[:n - first] = x[first:]
              self.buf_idx = (self.buf_idx + n) % L
              if end >= L:
                  self.filled = True

          def _compute_bpm(self):
              sig = np.concatenate((self.buffer[self.buf_idx:], self.buffer[:self.buf_idx]))
              sig = sig - np.mean(sig)
              N = len(sig)
              padded = np.concatenate([sig, np.zeros(N, dtype=np.float32)])
              spec = np.fft.rfft(padded)
              ac = np.fft.irfft(np.abs(spec) ** 2)[:N]
              if ac[0] <= 0:
                  return
              ac = ac / ac[0]
              tmin = min(self.tau_min, N - 2)
              tmax = min(self.tau_max, N - 2)
              if tmin >= tmax:
                  return
              k = int(np.argmax(ac[tmin:tmax + 1])) + tmin
              if ac[k] < self.corr_threshold:
                  return
              if 0 < k < N - 1:
                  a, b, c = ac[k - 1], ac[k], ac[k + 1]
                  denom = a - 2.0 * b + c
                  delta = 0.5 * (a - c) / denom if denom != 0 else 0.0
                  period = (k + delta) / self.fs
              else:
                  period = k / self.fs
              if period > 0:
                  self.current_bpm = float(np.clip(60.0 / period, 0.0, 60.0))

          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]
              n = len(x)
              self._push(x)
              self.since_update += n
              if self.filled and self.since_update >= self.update_every:
                  self._compute_bpm()
                  self.since_update = 0
              out[:n] = np.float32(self.current_bpm)
              return n
    bpm_max: '30.0'
    bpm_min: '3.0'
    corr_threshold: '0.3'
    samp_rate: '500'
    window_sec: '60.0'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    samp_delay: '500'
    taps: firwin(2001, [0.1, 0.5], pass_zero=False, fs=500)
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '100000'
    decim: '2000'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 100, 50, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_gain
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from scipy.signal import firwin
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,0,2,2
    name: '"Raw IQ Constellation"'
    size: '500'
    type: complex
    ymax: '0.15'
    ymin: '-0.15'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '500'
    fc: '0'
    fftsize: '8192'
    gui_hint: 2,0,1,4
    label: breathing Spectrum
    name: '"Breathing Spectrum"'
    showports: 'True'
    type: float
    wintype: window.WIN_HANN
    ymax: '20'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,2,1,1
    label1: FFT BPM
    max: '40'
    min: '0'
    name: '"FFT BPM"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,3,1,1
    label1: ZC BPM
    max: '40'
    min: '0'
    name: '"ZC BPM"'
    type: float
    unit1: BPM
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,2,1,2
    label1: AC BPM
    max: '40'
    min: '0'
    name: '"AC BPM"'
    type: float
    unit1: BPM
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 4,0,1,4
    name: '"Motion Detection"'
    size: '500'
    srate: '500'
    type: float
    update_time: '0.010'
    ymax: '0.5'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 3,0,1,4
    name: '"Breathing Waveform (20 s)"'
    size: '10000'
    srate: '500'
    type: float
    update_time: '0.010'
    ylabel: Phase (rad)
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"Motion Detected (1) / Not (0)"'
    size: '500'
    srate: '500'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [blocks_complex_to_arg_0, '0', epy_block_0, '0']
- [blocks_complex_to_arg_0_0, '0', epy_block_0_0, '0']
- [dc_blocker_xx_0, '0', blocks_complex_to_arg_0, '0']
- [epy_block_0, '0', fir_filter_xxx_0, '0']
- [epy_block_0_0, '0', epy_block_1, '0']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0, '0']
- [epy_block_2, '0', qtgui_time_sink_x_2, '0']
- [epy_block_3, '0', qtgui_number_sink_0, '0']
- [epy_block_4, '0', qtgui_number_sink_1, '0']
- [epy_block_5, '0', qtgui_number_sink_2, '0']
- [fir_filter_xxx_0, '0', epy_block_3, '0']
- [fir_filter_xxx_0, '0', epy_block_4, '0']
- [fir_filter_xxx_0, '0', epy_block_5, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_arg_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', dc_blocker_xx_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [iio_pluto_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
